# Keil uVision project SweepRobot.uvproj, settings and files
target DB-ROBOT-S1 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: DB-ROBOT-S1 +hex
  c flags: Optim=1
  c define: DEBUG_LOG NDEBUG REVISION_1_1 STM32F10X_HD CLOCK_HSE USE_STDPERIPH_DRIVER KEY_PROC_WITH_REMOTE  KEY_PROC_WITH_LED
  c include: ..\..\User\APP;..\..\User\BSP\inc;..\..\User\Framework\Common\inc;..\..\User\Framework\UI;..\..\User\Framework;..\..\Libraries\CMSIS\CoreSupport;..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\Libraries\CMSIS\Device\ST\STM32F10x;..\..\Libraries\STM32F10x_Ext\inc;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_hd_vl.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s
  group CMSIS
    ../../Libraries/CMSIS/CoreSupport/: core_cm3.c
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/: system_stm32f10x.c
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../../User/BSP/src/: BatteryManage.c Buzzer.c IrDA.c Measurement.c MotorCtrl.c PWM.c RTC.c
    ../../User/Framework/UI/: CtrlPanel.c key.c
    ../../User/: main.c
    ../../User/Framework/: MotionCtrl.c MsgQueue.c
    ../../User/Framework/Common/src/: PwrManagement.c
  group User_APP
    ../../User/APP/: SweepRobot.c
  group User_SYS
    ../../User/: boardcfg.h stm32f10x_conf.h
    ../../User/Framework/Common/src/: delay.c nvram.c
    ../../Libraries/STM32F10x_Ext/src/: stm32f10x_it.c Usart.c
