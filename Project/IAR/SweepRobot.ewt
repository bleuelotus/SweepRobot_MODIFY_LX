<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>DB-ROBOT-S1</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>CMSIS</name>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Source\Templates\iar\startup_stm32f10x_cl.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Source\Templates\iar\startup_stm32f10x_hd.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Source\Templates\iar\startup_stm32f10x_hd_vl.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Source\Templates\iar\startup_stm32f10x_ld.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Source\Templates\iar\startup_stm32f10x_ld_vl.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Source\Templates\iar\startup_stm32f10x_md.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Source\Templates\iar\startup_stm32f10x_md_vl.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Source\Templates\iar\startup_stm32f10x_xl.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Source\Templates\system_stm32f10x.c</name>
    </file>
  </group>
  <group>
    <name>LIB</name>
    <group>
      <name>STM32F10x_Ext</name>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_Ext\src\i2c_hw.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_Ext\src\i2c_sw.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_Ext\src\spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_Ext\src\spi_sw.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_Ext\src\stm32f10x_it.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_Ext\src\stm32f10x_UserMEM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_Ext\src\Usart.c</name>
      </file>
    </group>
    <group>
      <name>STM32F10x_StdPeriph_Driver</name>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\misc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_bkp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_can.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_cec.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_crc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_dac.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_dbgmcu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_exti.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_fsmc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_iwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_pwr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_rcc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_sdio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_tim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_usart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_wwdg.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>USER</name>
    <group>
      <name>APP</name>
      <file>
        <name>$PROJ_DIR$\..\..\User\APP\SweepRobot.c</name>
      </file>
    </group>
    <group>
      <name>BSP</name>
      <file>
        <name>$PROJ_DIR$\..\..\User\BSP\src\BatteryManage.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\User\BSP\src\ET6204.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\User\BSP\src\IrDA.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\User\BSP\src\Measurement.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\User\BSP\src\MotorCtrl.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\User\BSP\src\nrf24l01.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\User\BSP\src\PWM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\User\BSP\src\RTC.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\User\BSP\src\WTV040.c</name>
      </file>
    </group>
    <group>
      <name>Framework</name>
      <group>
        <name>Common</name>
        <file>
          <name>$PROJ_DIR$\..\..\User\Framework\Common\src\delay.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\User\Framework\Common\src\nvram.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\User\Framework\Common\src\PwrManagement.c</name>
        </file>
      </group>
      <group>
        <name>UI</name>
        <file>
          <name>$PROJ_DIR$\..\..\User\Framework\UI\CtrlPanel.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\User\Framework\UI\key.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\User\Framework\MotionCtrl.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\User\Framework\MsgQueue.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\User\boardcfg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\User\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\User\stm32f10x_conf.h</name>
    </file>
  </group>
</project>


